# Keil uVision project cm0plus.uvprojx, settings and files
target certification (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CY8C6347BZI-BLD53_Pack:CortexM0p Cypress
  pack: Cypress.Pack.5.2.4
  cpu: IRAM(0x8000000,0x48000) IROM(0x10000000,0x100000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: cm0plus
  AfterMake: $KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\postbuildCortexM0p.bat "#L" -p "$P" "cmsis" "$KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\win\elf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\platform\mcu\cy8c6347\drivers;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\drivers\peripheral;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\cmsis\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\ip;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\psoc63\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\middleware;..\..\..\..\kernel\rhino\core\include;..\..\..\..\board\cy8ckit-062;..\..\..\..\platform\arch\arm\armv7m\armcc\m4
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x8000000 size 0x48000
  scatter file: ..\..\..\..\platform\mcu\cy8c6347\drivers\linker_file\cy8c6xx7_cm0plus.scat
  group main
    ../../../../platform/mcu/cy8c6347/drivers/: cy_ipc_config.c main_cm0p.c system_psoc63_cm0plus.c
  group Generated_Source
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/: cyfitter_cfg.c cyfitter_sysint_cfg.c cymetadata.c
  group startup
    ../../../../platform/mcu/cy8c6347/drivers/startup/: startup_psoc63_cm0plus.s
  group PDL
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/flash/: cy_flash.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/gpio/: cy_gpio.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/ipc/: cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysclk/: cy_sysclk.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysint/: cy_sysint.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/: cy_syslib.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syspm/: cy_syspm.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/systick/: cy_systick.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/wdt/: cy_wdt.c

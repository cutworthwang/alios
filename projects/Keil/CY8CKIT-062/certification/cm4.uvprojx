# Keil uVision project cm4.uvprojx, settings and files
target certification (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CY8C6347BZI-BLD53_Pack:CortexM4 Cypress
  pack: Cypress.Pack.5.2.4
  cpu: IRAM(0x8000000,0x48000) IROM(0x10000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: cm4
  AfterMake: $KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\postbuildCortexM4.bat "#L" -p "$P" "cmsis" "$KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\win\elf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BUILD_BIN, AOS_ATCMD, RHINO_CONFIG_TICK_TASK=0, RHINO_CONFIG_WORKQUEUE=1, HAVE_NOT_ADVANCED_FORMATE, DEV_SAL_MK3060, WITH_SAL, AOS_VFS, CONFIG_AOS_CLI, AOS_KV,  AOS_LOOP, VCALL_RHINO, AOS_FOTA, AOS_FRAMEWORK_COMMON
  c misc: -DSYSINFO_OS_VERSION=\"APP-1.0.0-20180130.1211\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_CY8C6347BZI\" -DSYSINFO_DEVICE_NAME=\"CY8C6347BZI\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.2.0\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE
  c include: ..\..\..\..\include;..\..\..\..\include\aos;..\..\..\..\kernel\modules\fs\kv\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\kernel\vcall\aos;..\..\..\..\kernel\vcall\mico\include;..\..\..\..\kernel\vfs\include;..\..\..\..\kernel\vfs\include\device;..\..\..\..\kernel\yloop;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\board\cy8ckit-062;..\..\..\..\platform\arch\arm\armv7m\armcc\m4;..\..\..\..\device\sal\wifi\mk3060;..\..\..\..\device\sal\include;..\..\..\..\framework\atparser;..\..\..\..\utility\iotx-utils\sdk-impl;..\..\..\..\utility\iotx-utils\guider;..\..\..\..\utility\iotx-utils\iotx-system;..\..\..\..\utility\iotx-utils\LITE-log;..\..\..\..\utility\iotx-utils\LITE-utils;..\..\..\..\utility\iotx-utils\misc;..\..\..\..\utility\iotx-utils\digest;..\..\..\..\framework\fota\platform;..\..\..\..\framework\fota\download;..\..\..\..\framework\fota;..\..\..\..\utility\digest_algorithm;..\..\..\..\framework\fota\download\http\socket;..\..\..\..\platform\mcu\cy8c6347\wifi\inc;..\..\..\..\platform\mcu\cy8c6347\es_wifi;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\drivers\peripheral;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\cmsis\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\ip;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\psoc63\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\middleware;..\..\..\..\platform\mcu\cy8c6347\drivers;..\..\..\..\utility\cjson\include;..\..\..\..\security\mbedtls\include;..\..\..\..\framework\netmgr\include;..\..\..\..\security\alicrypto\libalicrypto\inc;..\..\..\..\test\testcase\include;..\..\..\..\test\yunit\include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x8000000 size 0x48000
  scatter file: ..\..\..\..\platform\mcu\cy8c6347\drivers\linker_file\cy8c6xx7_cm4_dual.scat
  group kernel/hal
    ../../../../kernel/hal/: ota.c wifi.c
  group kernel/init
    ../../../../kernel/init/: aos_init.c
  group kernel/modules/fs/kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group kernel/rhino/common
    ../../../../kernel/rhino/common/: k_fifo.c k_trace.c
  group kernel/rhino/core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group kernel/vcall/aos
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group kernel/vcall/mico
    ../../../../kernel/vcall/mico/: mico_rhino.c
  group kernel/vfs
    ../../../../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c vfs_file.c select.c
  group kernel/yloop
    ../../../../kernel/yloop/: local_event.c yloop.c
  group board/cy8ckit-062
    ../../../../board/cy8ckit-062/: board.c
  group device/sal
    ../../../../device/sal/: ip4_addr.c sal.c sal_arch.c sal_device.c sal_err.c sal_sockets.c
  group device/sal/wifi/mk3060
    ../../../../device/sal/wifi/mk3060/: mk3060.c wifi_atcmd.c
  group framework/atparser
    ../../../../framework/atparser/: atparser.c
  group framework/common
    ../../../../framework/common/: main.c version.c
  group framework/connectivity/mqtt
    ../../../../framework/connectivity/mqtt/: mqtt_client.c
  group framework/connectivity/mqtt/MQTTPACKET
    ../../../../framework/connectivity/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group framework/fota
    ../../../../framework/fota/: ota_service.c ota_update_manifest.c ota_util.c ota_version.c
  group framework/fota/download
    ../../../../framework/fota/download/: download_common.c
  group framework/fota/download/http
    ../../../../framework/fota/download/http/: ota_download.c
  group framework/fota/download/http/socket/stand
    ../../../../framework/fota/download/http/socket/stand/: ota_socket.c
  group framework/fota/platform
    ../../../../framework/fota/platform/: ota_platform_os.c
  group framework/fota/platform/mqtt
    ../../../../framework/fota/platform/mqtt/: ota_transport.c
  group framework/netmgr
    ../../../../framework/netmgr/: netmgr.c
  group platform/arch/arm/armv7m/armcc/m4
    ../../../../platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.s
  group platform/mcu/cy8c6347/aos
    ../../../../platform/mcu/cy8c6347/aos/: soc_impl.c trace_impl.c
  group platform/mcu/cy8c6347/hal
    ../../../../platform/mcu/cy8c6347/hal/: flash_port.c hw.c ota_port.c uart_port.c
  group platform/mcu/cy8c6347/runapp
    ../../../../platform/mcu/cy8c6347/runapp/: aos.c
  group security/alicrypto/lib/cortex-m4/keil
    ../../../../security/alicrypto/lib/Cortex-M4/KEIL/: libalicrypto.lib libmbedcrypto.lib
  group security/mbedtls/lib/cortex-m4/keil
    ../../../../security/mbedtls/lib/Cortex-M4/KEIL/: libmbedtls.lib
  group tools/cli
    ../../../../tools/cli/: cli.c dumpsys.c
  group utility/cjson
    ../../../../utility/cjson/: cJSON.c
  group utility/digest_algorithm
    ../../../../utility/digest_algorithm/: CheckSumUtils.c crc.c digest_algorithm.c md5.c
  group utility/iotx-utils/digest
    ../../../../utility/iotx-utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
  group utility/iotx-utils/guider
    ../../../../utility/iotx-utils/guider/: guider.c
  group utility/iotx-utils/hal/rhino
    ../../../../utility/iotx-utils/hal/rhino/: HAL_OS_rhino.c HAL_TCP_rhino.c
  group utility/iotx-utils/iotx-system
    ../../../../utility/iotx-utils/iotx-system/: ca.c device.c
  group utility/iotx-utils/LITE-log
    ../../../../utility/iotx-utils/LITE-log/: lite-log.c
  group utility/iotx-utils/LITE-utils
    ../../../../utility/iotx-utils/LITE-utils/: json_parser.c json_token.c mem_stats.c string_utils.c
  group utility/iotx-utils/mbedtls-hal
    ../../../../utility/iotx-utils/mbedtls-hal/: HAL_TLS_mbedtls.c
  group utility/iotx-utils/misc
    ../../../../utility/iotx-utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
  group utility/iotx-utils/sdk-impl
    ../../../../utility/iotx-utils/sdk-impl/: sdk-impl.c
  group utility/libc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group utility/log
    ../../../../utility/log/: log.c
  group system
    ../../../../platform/mcu/cy8c6347/drivers/: cy_ipc_config.c system_psoc63_cm4.c
  group Generated_Source
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/: cyfitter_cfg.c cyfitter_sysint_cfg.c cymetadata.c UART1.c UART5.c
  group startup
    ../../../../platform/mcu/cy8c6347/drivers/startup/: startup_psoc63_cm4.s
  group PDL
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/flash/: cy_flash.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/gpio/: cy_gpio.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/ipc/: cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/scb/: cy_scb_common.c cy_scb_ezi2c.c cy_scb_i2c.c cy_scb_spi.c cy_scb_uart.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysclk/: cy_sysclk.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysint/: cy_sysint.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/: cy_syslib.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syspm/: cy_syspm.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/systick/: cy_systick.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/wdt/: cy_wdt.c
  group certification
    ../../../../test/testcase/certificate_test/: aos_test.c
    ../../../../test/testcase/certificate_test/cutest/: cut.c
    ../../../../example/yts/: main.c
    ../../../../test/testcase/: yts_main.c
    ../../../../test/yunit/: yunit.c
    ./auto/: testcase_register.c
  group security/mbedtls
    ../../../../security/mbedtls/src/: mbedtls_net.c mbedtls_ssl.c

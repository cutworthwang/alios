# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I_Discovery
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F7469I_DISCO
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32F769xx\" -DSYSINFO_DEVICE_NAME=\"STM32F769xx\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.2.1\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\platform\mcu\stm32f7xx\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\platform\mcu\stm32f7xx\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\platform\mcu\stm32f7xx\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\mcu\stm32f7xx\Drivers\CMSIS\Include;..\..\..\..\platform\mcu\stm32f7xx\Drivers\BSP\STM32F769I-Discovery;..\..\..\..\platform\mcu\stm32f7xx\Drivers\BSP\Components\otm8009a;..\..\..\..\platform\mcu\stm32f7xx\hal;..\..\..\..\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv7m\armcc\m7;..\..\..\..\platform\mcu\stm32f7xx\src\STM32F769I-Discovery\lcd;..\..\..\..\include\hal;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group platform\mcu\stm32f7xx\Drivers\BSP\STM32F769I-Discovery
    ../../../../platform/mcu/stm32f7xx/Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sdram.c
  group platform\mcu\stm32f7xx\Drivers\STM32F7xx_HAL_Driver\Src
    ../../../../platform/mcu/stm32f7xx/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_uart.c stm32f7xx_ll_tim.c stm32f7xx_ll_pwr.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc_ex.c
  group platform\mcu\stm32f7xx\src\STM32F769I-Discovery
    ../../../../platform/mcu/stm32f7xx/src/STM32F769I-Discovery/: startup_stm32f769xx_keil.s
    ../../../../platform/mcu/stm32f7xx/src/STM32F769I-Discovery/lcd/: soc_init.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group platform\mcu\stm32f7xx\aos
    ../../../../platform/mcu/stm32f7xx/aos/: soc_impl.c trace_impl.c
  group platform\arch\arm\armv7m\armcc\m7
    ../../../../platform/arch/arm/armv7m/armcc/m7/: port_c.c port_s.S
  group example
    ../../../../example/rhinorun/: rhinorun.c
  group platform\mcu\stm32f7xx\Drivers\BSP\Components\otm8009a
    ../../../../platform/mcu/stm32f7xx/Drivers/BSP/Components/otm8009a/: otm8009a.c
  group platform\mcu\stm32f7xx\hal
    ../../../../platform/mcu/stm32f7xx/hal/: cache.c
  group utility\libc\compilers\armlibc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
software components: CMSIS:CORE 5.0.2
